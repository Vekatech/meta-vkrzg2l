COMPATIBLE_MACHINE_vkrzg2l = "vkrzg2l"

PLATFORM_FLAVOR_vkrzg2l = "g2l_smarc_2"

